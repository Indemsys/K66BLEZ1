# IAR project LED_StateMachine.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK66FN2M0xxx18 NXP MK66FN2M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: MK66FN2M0xxx18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group (top)
    ./: K66BLEZ1_GPIO.c K66BLEZ1_GPIO.h K66BLEZ1_INIT_SYS.c K66BLEZ1_INIT_SYS.h K66BLEZ1_UART.c K66BLEZ1_UART.h LED_StateMachine.c LED_StateMachine.h main.c main.h MK65F18.h Print_utils.c Print_utils.h startup_MK66F18.s
