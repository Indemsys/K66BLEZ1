# IAR project FatFS_test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK66FN2M0xxx18 Freescale MK66FN2M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK66FN2M0VMD18; FRDM_K66F; FREEDOM
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..\Debug; ..\Drivers; ..\FatFS; ..\SDMMC; ..\..\FatFS_test
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: FatFS_test.out
  ILINK.IlinkIcfFile: MK66FN2M0xxx18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK66FN2M0VMD18; FRDM_K66F; FREEDOM
  ICCARM.CCOptLevel: 3
  group FatFS_test
    ../../FatFS_test/: board.c clock_config.c event.c pin_mux.c sdcard_fatfs.c startup_MK66F18.s system_MK66F18.c
  group FatFS_test/Debug
    ../Debug/: fsl_debug_console.c
  group FatFS_test/Drivers
    ../Drivers/: fsl_clock.c fsl_common.c fsl_gpio.c fsl_lpuart.c fsl_mpu.c fsl_sdhc.c fsl_smc.c fsl_uart.c
  group FatFS_test/FatFS
    ../FatFS/: diskio.c ff.c fsl_sd_disk.c
  group FatFS_test/SDMMC
    ../SDMMC/: fsl_mmc.c fsl_sd.c fsl_sdmmc.c
