# IAR project HID_dev_freeRTOS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKW40Z160xxx4 Freescale MKW40Z160xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; IAR; CPU_MKW40Z160VHT4; FSL_RTOS_FREE_RTOS; USB_KW40Z; DONGLE
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.PreInclude: C:\Embedded\Projects\K66BLEZ\Firmware\MKW40\HID_device\App\app_preinclude.h
  ICCARM.CCIncludePath2: ..\App\gatt_db\macros; ..\App\gatt_db; ..\App; ..\Bluetooth; ..\CMSIS; ..\Framework\Flash; ..\Framework; ..\FreeRTOS\config; ..\FreeRTOS\include; ..\FreeRTOS\port; ..\HAL; ..\OSA; ..\Peripherial
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: HID_dev_freeRTOS.bin
  ILINK.IlinkOutputFile: hid_device_FreeRTOS.out
  ILINK.IlinkConfigDefines: gUseNVMLink_d=1; __heap_size__=0; __stack_size__=384; __ram_vector_table__=1
  ILINK.IlinkIcfFile: MKW40Z160xxx4_connectivity.icf
  ILINK.IlinkAdditionalLibs: C:\Embedded\Projects\K66BLEZ\Firmware\MKW40\HID_device\Bluetooth\ble_host_peripheral_lib.a; C:\Embedded\Projects\K66BLEZ\Firmware\MKW40\HID_device\Bluetooth\lib_crypto_IAR_M0.a; C:\Embedded\Projects\K66BLEZ\Firmware\MKW40\HID_device\Bluetooth\ble_controller_lib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; IAR; CPU_MKW40Z160VHT4
  ICCARM.PreInclude: examples/bluetooth/hid_device/frdmkw40z/FreeRTOS/app_preinclude.h
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: generic.bin
  ILINK.IlinkIcfFile: platform/devices/MKW40Z4/linker/iar/MKW40Z160xxx4_connectivity.icf
  ILINK.IlinkAdditionalLibs: bluetooth/host/lib/ble_host_peripheral_lib.a; $_KSDK_1_3_0_PATH_$\lib\ksdk_freertos_lib\iar\KW40Z4\release\libksdk_platform_freertos.a; framework/SecLib/lib_crypto_IAR_M0.a; bluetooth/controller/lib/ble_controller_lib.a
  group HID_device/App
    ../App/: ApplMain.c app_config.c ble_controller_task.c ble_host_tasks.c ble_init.c board.c gpio_pins.c hardware_init.c HID_dev_app.c pin_mux.c startup.c startup_MKW40Z4.s system_MKW40Z4.c
  group HID_device/App/gatt_db
    ../App/gatt_db/: gatt_database.c
  group HID_device/Bluetooth
    ../Bluetooth/: battery_service.c ble_globals.c device_info_service.c hcit_serial_interface.c hid_service.c
  group HID_device/Framework
    ../Framework/: DCDC.c fsl_osa_ext_freertos.c FunctionLib.c FwkInit.c GenericList.c GPIO_IrqAdapter.c ifr_mkw40z4_radio.c Keyboard.c KW4xXcvrDrv.c LED.c MemManager.c Messaging.c Panic.c Reset.c RNG.c SecLib.c SerialManager.c TimersManager.c TMR_Adapter.c tsm_ll_timing.c
  group HID_device/Framework/Flash
    ../Framework/Flash/: CopyToRam.c DEFlashPartition.c DFlashGetProtection.c DFlashSetProtection.c EEEWrite.c EERAMGetProtection.c EERAMSetProtection.c FlashCheckSum.c FlashCommandSequence.c FlashEraseAllBlock.c FlashEraseResume.c FlashEraseSector.c FlashEraseSuspend.c FlashGetSecurityState.c FlashInit.c FlashProgram.c FlashProgramCheck.c FlashProgramOnce.c FlashProgramSection.c FlashReadOnce.c FlashReadResource.c FlashSecurityBypass.c FlashVerifyAllBlock.c FlashVerifyBlock.c FlashVerifySection.c Flash_Adapter.c PFlashGetProtection.c PFlashSetProtection.c PFlashSwap.c PFlashSwapCtl.c SetEEEEnable.c
  group HID_device/FreeRTOS/port
    ../FreeRTOS/port/: port.c portasm.s
  group HID_device/FreeRTOS/src
    ../FreeRTOS/src/: croutine.c event_groups.c heap_1.c heap_2.c heap_3.c heap_4.c heap_5.c list.c queue.c tasks.c timers.c
  group HID_device/HAL
    ../HAL/: fsl_adc16_hal.c fsl_cmp_hal.c fsl_cmt_hal.c fsl_cop_hal.c fsl_dac_hal.c fsl_dmamux_hal.c fsl_dma_hal.c fsl_dspi_hal.c fsl_gpio_hal.c fsl_i2c_hal.c fsl_llwu_hal.c fsl_lptmr_hal.c fsl_ltc_hal.c fsl_mcg_hal.c fsl_mcg_hal_modes.c fsl_pit_hal.c fsl_port_hal.c fsl_rcm_hal.c fsl_rtc_hal.c fsl_sim_hal_MKW40Z4.c fsl_smc_hal.c fsl_tpm_hal.c fsl_trng_hal.c fsl_tsi_hal.c fsl_tsi_v4_hal_specific.c
  group HID_device/OSA
    ../OSA/: fsl_os_abstraction_free_rtos.c
  group HID_device/Peripherial
    ../Peripherial/: fsl_adc16_common.c fsl_adc16_driver.c fsl_clock_manager.c fsl_clock_manager_common.c fsl_clock_MKW40Z4.c fsl_cmp_common.c fsl_cmp_driver.c fsl_cmt_common.c fsl_cmt_driver.c fsl_cop_common.c fsl_cop_driver.c fsl_dac_common.c fsl_dac_driver.c fsl_dma_common.c fsl_dma_driver.c fsl_dspi_common.c fsl_dspi_dma_master_driver.c fsl_dspi_dma_slave_driver.c fsl_dspi_master_driver.c fsl_dspi_shared_function.c fsl_dspi_slave_driver.c fsl_gpio_common.c fsl_gpio_driver.c fsl_hwtimer.c fsl_hwtimer_pit.c fsl_hwtimer_systick.c fsl_i2c_common.c fsl_i2c_master_driver.c fsl_i2c_shared_function.c fsl_i2c_slave_driver.c fsl_interrupt_manager.c fsl_lptmr_common.c fsl_lptmr_driver.c fsl_lpuart_common.c fsl_lpuart_dma_driver.c fsl_lpuart_driver.c fsl_ltc_common.c fsl_ltc_driver.c fsl_ltc_driver_aes.c fsl_ltc_driver_aes_ccm.c fsl_ltc_driver_hash.c fsl_pit_common.c fsl_pit_driver.c fsl_power_manager.c fsl_rtc_common.c fsl_rtc_driver.c fsl_tpm_common.c fsl_tpm_driver.c fsl_trng_common.c fsl_trng_driver.c fsl_tsi_common.c fsl_tsi_driver.c fsl_tsi_v4_driver_specific.c
